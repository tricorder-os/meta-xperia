EXTRA_OECONF += " --enable-obsolete"
